# KOMPAS-3D part (Pipe_Tanks_step 2_41.m3d)

Model tree:
1. X Axis
2. Y Axis
3. Z Axis  (labels: Pipe Dn 50)
     Òîëùèíà ñòåíêè 1 = 1

Referenced files in C:\Documents and Settings\kashirsky\Мои документы\Camtasia Studio\Pipelines3D\Tanks\: Tanks_step 2.a3d
Texts:
  Pipe Dn 50
  Steel ASTM A295
  Three Point Plane
  Plane at Angle
  Line and Point Plane
  Axis through Two Vertices
  Axis of Feature
  Axis of Conical Surface
  Axis through Edge
  Trim by Surface
  Trim by Sketch
  Feature with No History
  Intersection Axis of Two Planes
  Two Line Plane
  Line and Face Plane
  Bend by line
  Hole in sheet body
  Cut in sheet body
  Point in CM
  Linear Dimension from Line to Point
  Surface Finish Symbol
  Geometric Tolerance Symbol
  Leader #1
  Leader #2
  Leader #3
  Shape Deviations and Datum
  Node point number
  Mark of coordination axis
  Node point designation
  Mark/Reference designation with leader
  Mark/reference designation on line
  Mark/Reference designation without leader
  Plane of section